# Keil uVision project wawa1.uvprojx, settings and files
target wawa1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wawa_servo +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;.\PrintForDebug;.\Delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c servo.c imu.c audio.c comunicate.c debug.c key.c LCD5110.C
    ./Delay/: delay.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/dma/: stm32f10x_dma.c stm32f10x_dma.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
  group PrintForDebug
    ./PrintForDebug/: print_redirect_function.c
software components: CMSIS:CORE 4.3.0
